options:
  parameters:
    author: Deepwave Digital, Inc
    category: Custom
    description: Example for Wavelearner Inference Block
    generate_options: no_gui
    id: classifier_test
    output_language: python
    run_options: run
    title: Classifier Test
  states: {}

blocks:
- name: batch_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: input_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: output_len
  id: variable
  parameters:
    value: '12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 31.25e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output.bin
    type: float
    vlen: output_len*batch_size
  states: {}
- name: buffer0
  id: blocks_stream_to_vector
  parameters:
    num_items: batch_size*input_len
    type: complex
  states: {}
- name: inference
  id: wavelearner_inference
  parameters:
    batch_size: batch_size
    input_type: complex
    input_vlen: input_len*batch_size
    output_vlen: output_len*batch_size
    plan_filepath: saved_model.plan
  states: {}
- name: soapy_airt_source_0
  id: soapy_airt_source
  parameters:
    agc: 'True'
    center_freq: frequency
    dev_args: ''
    gain0: '0'
    gain1: '0'
    nchan: '1'
    samp_rate0: samp_rate
    samp_rate1: samp_rate
    type: fc32
  states: {}

connections:
- [buffer0, '0', inference, '0']
- [inference, '0', blocks_file_sink_0, '0']
- [soapy_airt_source_0, '0', buffer0, '0']

metadata:
  file_format: 1
