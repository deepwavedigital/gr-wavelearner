<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>classifier_test</value></param>
<param><key>author</key><value>Deepwave Digital, Inc</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Example for Wavelearner Inference Block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>Classifier Test</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>batch_size</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>input_len</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>output_len</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>31.25e6</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>buffer0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>batch_size*input_len</value></param>
</block>
<block>
<key>wavelearner_inference</key>
<param><key>id</key><value>inference</value></param>
<param><key>batch_size</key><value>batch_size</value></param>
<param><key>input_type</key><value>complex</value></param>
<param><key>input_vlen</key><value>input_len*batch_size</value></param>
<param><key>output_vlen</key><value>output_len*batch_size</value></param>
<param><key>plan_filepath</key><value>saved_model.plan</value></param>
</block>
<block>
<key>soapy_source</key>
<param><key>id</key><value>soapy_source_0</value></param>
<param><key>sdrplay_biastee</key><value>true</value></param>
<param><key>ant0</key><value></value></param>
<param><key>dc_offset_auto_mode0</key><value>True</value></param>
<param><key>gain_auto_mode0</key><value>True</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>dc_offset0</key><value>0</value></param>
<param><key>correction0</key><value>0</value></param>
<param><key>fine_tune0</key><value>False</value></param>
<param><key>overall_gain0</key><value>0</value></param>
<param><key>balance0</key><value>0</value></param>
<param><key>lna_gain0</key><value>0</value></param>
<param><key>mix_gain0</key><value>0</value></param>
<param><key>pga_gain0</key><value>0</value></param>
<param><key>tuner_gain0</key><value>0</value></param>
<param><key>vga_gain0</key><value>0</value></param>
<param><key>ant1</key><value></value></param>
<param><key>dc_offset_auto_mode1</key><value>False</value></param>
<param><key>gain_auto_mode1</key><value>False</value></param>
<param><key>fine_tune1</key><value>False</value></param>
<param><key>overall_gain1</key><value>0</value></param>
<param><key>lna_gain1</key><value>0</value></param>
<param><key>mix_gain1</key><value>0</value></param>
<param><key>pga_gain1</key><value>0</value></param>
<param><key>tuner_gain1</key><value>0</value></param>
<param><key>vga_gain1</key><value>0</value></param>
<param><key>sdrplay_dabnotch</key><value>false</value></param>
<param><key>dev</key><value>"device=SoapyAIRT"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sdrplay_rfnotch</key><value>false</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wavelearner_terminal_sink</key>
<param><key>id</key><value>wavelearner_terminal_sink_0</value></param>
<param><key>batch_size</key><value>batch_size</value></param>
<param><key>input_vlen</key><value>output_len*batch_size</value></param>
</block>
<connection><source_block_id>buffer0</source_block_id><sink_block_id>inference</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inference</source_block_id><sink_block_id>wavelearner_terminal_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>soapy_source_0</source_block_id><sink_block_id>buffer0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
