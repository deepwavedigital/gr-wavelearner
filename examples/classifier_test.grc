<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>classifier_test</value></param>
<param><key>author</key><value>Deepwave Digital, Inc</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Test for Wavelearn Inference Block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Classifier Test</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>batch_size</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_path</value></param>
<param><key>value</key><value>"/usr/local/src/gr-wavelearner/examples/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fs</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>input_len</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>output_len</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>buffer0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>batch_size*input_len</value></param>
</block>
<block>
<key>wavelearner_inference</key>
<param><key>id</key><value>inference</value></param>
<param><key>batch_size</key><value>batch_size</value></param>
<param><key>input_type</key><value>float</value></param>
<param><key>input_vlen</key><value>input_len*batch_size</value></param>
<param><key>output_vlen</key><value>output_len*batch_size</value></param>
<param><key>plan_filepath</key><value>data_path + "classifier_test_tx2_trt4.plan"</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>source</value></param>
<param><key>file</key><value>data_path + "classifier_test.dat"</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>throttle</value></param>
<param><key>samples_per_second</key><value>fs</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>type_confert</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>wavelearner_terminal_sink</key>
<param><key>id</key><value>wavelearner_terminal_sink_0</value></param>
<param><key>batch_size</key><value>batch_size</value></param>
<param><key>input_vlen</key><value>output_len*batch_size</value></param>
</block>
<connection><source_block_id>buffer0</source_block_id><sink_block_id>inference</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inference</source_block_id><sink_block_id>wavelearner_terminal_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>source</source_block_id><sink_block_id>throttle</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>throttle</source_block_id><sink_block_id>type_confert</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>type_confert</source_block_id><sink_block_id>buffer0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
