<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cuda_fft_demo</value></param>
<param><key>author</key><value>Deepwave Digital</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>AIR-T Example</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_batch_size</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>3.1e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfft</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>31.25e6</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>nfft</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>nfft</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_batch_size*nfft</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_batch_size</value></param>
<param><key>vlen</key><value>nfft</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"cuFFT"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>vlen</key><value>nfft</value></param>
<param><key>x_axis_label</key><value>"Normalized Frequency"</value></param>
<param><key>x_start</key><value>-0.5</value></param>
<param><key>x_step</key><value>1.0/float(nfft)</value></param>
<param><key>ymin</key><value>-60</value></param>
<param><key>y_axis_label</key><value>"PSD (dB)"</value></param>
</block>
<block>
<key>soapy_source</key>
<param><key>id</key><value>soapy_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>dc_offset_auto_mode0</key><value>True</value></param>
<param><key>gain_auto_mode0</key><value>True</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>dc_offset0</key><value>0</value></param>
<param><key>correction0</key><value>0</value></param>
<param><key>fine_tune0</key><value>False</value></param>
<param><key>overall_gain0</key><value>0</value></param>
<param><key>balance0</key><value>0</value></param>
<param><key>lna_gain0</key><value>0</value></param>
<param><key>mix_gain0</key><value>0</value></param>
<param><key>pga_gain0</key><value>0</value></param>
<param><key>tuner_gain0</key><value>0</value></param>
<param><key>vga_gain0</key><value>0</value></param>
<param><key>ant1</key><value></value></param>
<param><key>dc_offset_auto_mode1</key><value>False</value></param>
<param><key>gain_auto_mode1</key><value>False</value></param>
<param><key>fine_tune1</key><value>False</value></param>
<param><key>overall_gain1</key><value>0</value></param>
<param><key>lna_gain1</key><value>0</value></param>
<param><key>mix_gain1</key><value>0</value></param>
<param><key>pga_gain1</key><value>0</value></param>
<param><key>tuner_gain1</key><value>0</value></param>
<param><key>vga_gain1</key><value>0</value></param>
<param><key>dev</key><value>"device=SoapyAIRT"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wavelearner_fft</key>
<param><key>id</key><value>wavelearner_fft_1</value></param>
<param><key>direction</key><value>True</value></param>
<param><key>fft_size</key><value>nfft</value></param>
<param><key>vlen</key><value>fft_batch_size*nfft</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>wavelearner_fft_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>soapy_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wavelearner_fft_1</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
