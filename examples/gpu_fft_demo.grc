options:
  parameters:
    author: Deepwave Digital
    category: Custom
    generate_options: qt_gui
    id: cuda_fft_demo
    output_language: python
    title: AIR-T Example
  states: {}

blocks:
- name: fft_batch_size
  id: variable
  parameters:
    value: '128'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 3.1e9
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 31.25e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_batch_size*nfft
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_batch_size
    type: complex
    vlen: nfft
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    name: '"cuFFT"'
    showports: 'True'
    update_time: '0.05'
    vlen: nfft
    x_axis_label: '"Normalized Frequency"'
    x_start: '-0.5'
    x_step: 1.0/float(nfft)
    y_axis_label: '"PSD (dB)"'
    ymin: '-60'
  states: {}
- name: soapy_airt_source_0
  id: soapy_airt_source
  parameters:
    agc: 'True'
    center_freq: frequency
    dev_args: ''
    gain0: '0'
    gain1: '0'
    nchan: '1'
    samp_rate0: samp_rate
    samp_rate1: samp_rate
    type: fc32
  states: {}
- name: wavelearner_fft_1
  id: wavelearner_fft
  parameters:
    fft_size: nfft
    forward_fft: 'True'
    vlen: fft_batch_size*nfft
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', wavelearner_fft_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_squared_0, '0']
- [soapy_airt_source_0, '0', blocks_stream_to_vector_0, '0']
- [wavelearner_fft_1, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
